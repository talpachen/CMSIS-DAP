# IAR project USBD_HID_Transfer.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC100DN series Nuvoton NUC100DN series (NUC100DN,NUC120DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; CMSIS; StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID_Transfer.bin
  ILINK.IlinkOutputFile: USBD_HID_Transfer.out
  ILINK.IlinkIcfFile: USBD_HID_Transfer.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    CMSIS/: core_cm0.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h NUC100Series.h startup_NUC100Series.s system_NUC100Series.c system_NUC100Series.h
  group CMSIS-DAP Core
    ../: DAP.c DAP.h descriptors.c JTAG_DP.c SW_DP.c
  group Library
    StdDriver/src/: clk.c fmc.c gpio.c retarget.c sys.c timer.c uart.c usbd.c
  group user
    ./: DAP_config.h hid.c hid.h main.c usb_hid.h
