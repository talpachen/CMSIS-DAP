# IAR project USBD_HID_Mouse.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC100DN series Nuvoton NUC100DN series (NUC100DN,NUC120DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; CMSIS; StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CMSIS-DAP_Nu-Link-Me.bin
  ILINK.IlinkOutputFile: USBD_HID_Mouse.out
  ILINK.IlinkIcfFile: USBD_HID_Mouse.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    CMSIS/: core_cm0.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h NUC100Series.h startup_NUC100Series.s system_NUC100Series.c system_NUC100Series.h
  group CMSIS-DAP Core
    ../: DAP.c DAP.h JTAG_DP.c SW_DP.c
    ./: main.c usbd_user_hid.c
  group Config
    ./: DAP_config.h usb_config.c
    ../: descriptors.c
  group Library
    StdDriver/src/: clk.c fmc.c gpio.c retarget.c sys.c timer.c uart.c usbd.c
